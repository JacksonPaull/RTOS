# Keil uVision project Lab4.uvprojx, settings and files
target Lab4 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab4
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab4.c
    ../inc/: LaunchPad.c PLL.c ADCT0ATrigger.c ADCSWTrigger.c cr4_fft_64_stm32.s LPF.c IRDistance.c WTimer0A.c Timer4A.c Timer5A.c Timer3A.c
    ../RTOS_Labs_common/: OS.c ST7735.c Interpreter.c UART0int.c eDisk.c eFile.c osasm.s ADC.c FIFOsimple.c
    ../RTOS_Lab2_RTOSkernel/: LinkedList.c scheduler.c
    ../RTOS_Lab3_RTOSpriority/: PriorityQueue.c
software components: CMSIS:CORE 5.6.0
