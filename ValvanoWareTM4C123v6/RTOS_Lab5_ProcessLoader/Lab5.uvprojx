# Keil uVision project Lab5.uvprojx, settings and files
target Lab5 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR LAB5
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --symdefs Lab5.def
  group Source
    ./: startup.s Lab5.c loader.c
    ../inc/: LaunchPad.c PLL.c ADCT0ATrigger.c ADCSWTrigger.c LPF.c IRDistance.c WTimer0A.c Timer3A.c Timer4A.c Timer5A.c
    ../RTOS_Labs_common/: OS.c ST7735.c Interpreter.c UART0int.c eDisk.c eFile.c osasm.s ADC.c heap.c FIFOsimple.c esp8266.c WifiSettings.h
    ../RTOS_Lab3_RTOSpriority/: PriorityQueue.c PriorityQueue.h
    ../RTOS_Lab2_RTOSkernel/: LinkedList.c scheduler.c scheduler.h
    ../RTOS_Lab4_FileSystem/: Bitmap.c
    ../driverlib/: mpu.c cpu.c interrupt.c
