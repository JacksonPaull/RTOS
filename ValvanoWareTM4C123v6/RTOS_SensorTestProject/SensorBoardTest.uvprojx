# Keil uVision project SensorBoardTest.uvprojx, settings and files
target SensorBoardTest (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SensorBoardTest
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s SensorBoardTestMain.c
    ../inc/: ADCSWTrigger.c CortexM.c IRDistance.c LaunchPad.c PLL.c ST7735.c Timer.c LPF.c I2CB1.c opt3101.c
software components: CMSIS:CORE 5.6.0
