# Keil uVision project VerySimpleApplicationProcessor.uvprojx, settings and files
target VerySimpleApplicationProcessor (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VerySimpleApplicationProcessor
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ../inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: VerySimpleApplicationProcessor.c
    ../inc/: AP.c CortexM.c GPIO.c Clock.c LaunchPad.c UART.c UART1int.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
