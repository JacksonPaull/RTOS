# Keil uVision project Lab3.uvprojx, settings and files
target Lab3 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab3.c PriorityQueue.c PriorityQueue.h
    ../RTOS_Labs_common/: OS.c Interpreter.c ST7735.c eDisk.c efile.c osasm.s UART0int.c ADC.c FIFOsimple.c
    ../inc/: LaunchPad.c PLL.c ADCSWTrigger.c ADCT0ATrigger.c LPF.c WTimer0A.c cr4_fft_64_stm32.s PID_stm32.s IRDistance.c Timer4A.c Timer3A.c Timer5A.c
    ../RTOS_Lab2_RTOSkernel/: scheduler.c scheduler.h LinkedList.c LinkedList.h
software components: CMSIS:CORE 6.1.0
