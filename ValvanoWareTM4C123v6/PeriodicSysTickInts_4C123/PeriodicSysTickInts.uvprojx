# Keil uVision project PeriodicSysTickInts.uvprojx, settings and files
target PeriodicSysTickInts (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PeriodicSysTickInts
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PeriodicSysTickInts.c
    ../inc/: PLL.c SysTickInts.c LaunchPad.c Texas.c
software components: CMSIS:CORE 5.6.0
